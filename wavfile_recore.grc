<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>145.910e6</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>frequ</value></param>
<param><key>value</key><value>freq</value></param>
<param><key>label</key><value>frequ</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>freq-10e6</value></param>
<param><key>step</key><value>1000</value></param>
<param><key>stop</key><value>freq+10e6</value></param>
<param><key>widget</key><value>slider</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>200000</value></param>
</block>
<block>
<key>blks2_packet_decoder</key>
<param><key>id</key><value>blks2_packet_decoder_0</value></param>
<param><key>access_code</key><value></value></param>
<param><key>type</key><value>float</value></param>
<param><key>threshold</key><value>-1</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_0</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>/home/kai/desktop/grc/BPSK_test_file</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_wavfile_sink</key>
<param><key>id</key><value>blocks_wavfile_sink_0</value></param>
<param><key>bits_per_sample</key><value>16</value></param>
<param><key>file</key><value>/home/kai/desktop/grc/wavtest0712014.wav</value></param>
<param><key>nchan</key><value>2</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>digital_dxpsk_demod</key>
<param><key>id</key><value>digital_dxpsk_demod_0</value></param>
<param><key>excess_bw</key><value>0.35</value></param>
<param><key>freq_bw</key><value>6.28/100.0</value></param>
<param><key>mod_code</key><value>"gray"</value></param>
<param><key>log</key><value>False</value></param>
<param><key>phase_bw</key><value>6.28/100.0</value></param>
<param><key>samples_per_symbol</key><value>2</value></param>
<param><key>sync_out</key><value>False</value></param>
<param><key>timing_bw</key><value>6.28/100.0</value></param>
<param><key>type</key><value>dbpsk</value></param>
<param><key>verbose</key><value>False</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>frequ</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>showrf</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>frequ</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>bw0</key><value>100000</value></param>
<param><key>center_freq0</key><value>frequ</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>0</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>type=usrp2,addr=192.168.10.2</value></param>
<param><key>dev_args</key><value>type=usrp2,addr=192.168.10.2</value></param>
<param><key>sd_spec0</key><value>A:0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>stream_args</key><value>peak=0.003906</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>blks2_packet_decoder_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>blocks_wavfile_sink_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>blocks_wavfile_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_dxpsk_demod_0</source_block_id><sink_block_id>blks2_packet_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>blocks_complex_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>digital_dxpsk_demod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>qtgui_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
